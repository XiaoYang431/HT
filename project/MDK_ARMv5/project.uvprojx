# Keil uVision project project.uvprojx, settings and files
target HT32 (6070000::V6.7::.\ARMCLANG)
  device: HT32F52367 Holtek
  pack: Holtek.HT32_DFP.1.0.63
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x3FC00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HT32 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HT32_DRIVER, USE_BM53A367A_DVB, USE_HT32F52357_67, USE_MEM_HT32F52367
  c include: ..\;..\..\library\CMSIS\Include;..\..\library\Device\Holtek\HT32F5xxxx\Include;..\..\library\HT32F5xxxx_Driver\inc;..\..\library\HT32_USBD_Library\inc;..\..\utilities;..\..\hardware;..\..\hardware;..\..\utilities\middleware
  asm define: USE_HT32_CHIP=11, USE_LIBCFG_RAM_SIZE=0x8000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3fc00
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group User
    ../: ht32f5xxxx_01_it.c main.c
  group Config
    ../: ht32f5xxxx_01_usbdconf.h ht32f5xxxx_conf.h
    ./: ht32_op.s HT32F5xxxx_01_DebugSupport.ini
  group CMSIS
    ../: system_ht32f5xxxx_03.c
  group MDK-ARM
    ./: startup_ht32f5xxxx_03.s
  group Retarget
    ../../library/HT32F5xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../../utilities/common/: i2c_eeprom.c spi_flash.c spi_lcd.c ring_buffer.c ring_buffer.h
    ../../utilities/: ht32_board.c
    ../../utilities/middleware/: i2c_master.c uart_module.c uart_module.h
  group Library
    ../../library/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_aes.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_cmp.c ht32f5xxxx_crc.c ht32f5xxxx_dac.c ht32f5xxxx_div.c ht32f5xxxx_ebi.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_i2s.c ht32f5xxxx_mctm.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_sci.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_usbd.c ht32f5xxxx_wdt.c
  group hardware
    ../../hardware/: PWM.c PWM.h GPS.c GPS.h BMP73T104.c BMP73T104.h SIM900A.c SIM900A.h BM32S2031_1.c BM32S2031_1.h Motor.c Motor.h Bizhnag.c Bizhang.h BMS56M605.c BMS56M605.h Kaerman.c Kaerman.h BM7701_00_1.c BM7701_00_1.h
  group USBD_Library
    ../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
